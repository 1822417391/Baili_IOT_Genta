# Keil uVision project VoltageIndicator.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: VoltageIndicator +hex
  c flags: Optimize=8 SizeSpeed=1
  group Headers
    ./: common.h stdint.h romhandler.h crc.h
  group Source Group 1
    ./: main.c romhandler.c crc.c
